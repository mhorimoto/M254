# Repository mhorimoto/M254

File README.md:

# NJM2903_Non-inverting_comparator_circuit_with_hysteresis

Author: Masafumi Horimoto

Voltage Amplifier & Comparator for CTT-10-CLS-CV-25

## Devices

Comparator [NJM2903D](https://akizukidenshi.com/catalog/g/g113486/)

## Simulation results

The CTT-10-CLS-CV-25 outputs 5V at 25A. If it detects 1A, it will fix the output at a 4V level if it detects a threshold of 0.2V.

## KiCad design M254.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 0.1uF; C_Disc_D3.4mm_W2.1mm_P2.50mm
FL1, FL2: DSS1NB31H104Q91; DSS1
J1: from Sensor1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2, J4: to M304; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: from Sensor2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1, R5: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R6: 2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R7: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4, R8: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1, RV2: 50k; Potentiometer_Bourns_3296W_Vertical
U1: NJM2903; DIP-8_W7.62mm_LongPads
V101, V102: 5

Connections:
+5V: C1.1, C2.1, C5.1, J2.3, J4.3, R1.1, R3.1, R5.1, R7.1, RV1.1, RV2.1, U1.8 (V+), V101.1
/Vin: FL1.1, J1.2, V102.1
/Vout: C3.1, J2.2, R3.2, R4.2, U1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, FL1.2, FL2.2, J1.1, J2.1, J3.1, J4.1, R2.2, R6.2, RV1.3, RV2.3, U1.4 (V-)
unnamed: FL2.1, J3.2
unnamed: C6.1, J4.2, R7.2, R8.2, U1.7
unnamed: C4.1, FL1.3, U1.3 (+)
unnamed: R1.2, R2.1, R4.1, RV1.2, U1.2 (-)
unnamed: C7.1, FL2.3, U1.5 (+)
unnamed: R5.2, R6.1, R8.1, RV2.2, U1.6 (-)
unnamed: V101.2, V102.2

Notes on the sheet:
可変させたいときにはRV 固定させるときにはR1,2

Board: 2 copper layers, 40.0 x 50.0 mm, 24 parts (0 on the bottom side), 10 nets.

## Commit log

2025-06-28 Document 整備
2025-06-29 DOCs
2025-07-04 continue モデル番号を変更する予定
2025-07-04 changed filenames
2025-07-06 一応PCB完成。温めて見直す
